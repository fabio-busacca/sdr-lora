options:
  parameters:
    author: SDR-LoRa
    description: 'LoRa receiver: it decodes standard LoRa frames at SF7 and 125 kHz, and prints each packet as text, together with its metadata.'
    generate_options: qt_gui
    id: lora_rx_usrp
    output_language: python
    title: LoRa receiver (USRP)
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 868.1e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"LoRa channel"'
    type: complex
  states: {}
- name: sdrlora_decoder_0
  id: sdrlora_decoder
  parameters:
    bw: bw
    center_freq: freq
    channel_filter_rx: 'True'
    cr: '1'
    cutoff_ratio: '1.15'
    fec_correct: 'True'
    has_crc: 'True'
    hop_freqs: '[]'
    hop_period: '0'
    implicit_header: 'False'
    interp_target_osf: '4'
    interpolate: 'True'
    invert_iq: 'False'
    ldro: '2'
    low_latency: 'False'
    max_payload_len: '251'
    min_osf: '2'
    numtaps: '255'
    payload_len: '0'
    pseudo_header: 'False'
    report_crc_errors: 'False'
    robust_sync: 'True'
    samp_rate: samp_rate
    search_tail_symbols: '24'
    sf: sf
    soft_decision: 'True'
    sync_phases: '0'
    sync_threshold: '5.5'
    sync_word: '[0x12]'
    trise: '50e-6'
    window: '0'
  states: {}
- name: sdrlora_packet_print_0
  id: sdrlora_packet_print
  parameters:
    label: ''
    show_hex: 'False'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [sdrlora_decoder_0, pdus, sdrlora_packet_print_0, pdus]
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', sdrlora_decoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
