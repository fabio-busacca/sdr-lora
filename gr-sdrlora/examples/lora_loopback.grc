options:
  parameters:
    author: SDR-LoRa
    description: Loopback from the LoRa Encoder to the LoRa Decoder through a noisy channel, with no radio. Every second, a PDU carrying 'Hello LoRa!' is encoded, noise is added, and the decoded packet is printed as text, together with its metadata. Moreover, the noise slider shows how the link degrades.
    generate_options: qt_gui
    id: lora_loopback
    output_language: python
    title: LoRa loopback (no radio)
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 868.1e6
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: '"Noise voltage"'
    start: '0'
    step: '0.05'
    stop: '3'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(11, list(b"Hello LoRa!")))
    period: '1000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise
    seed: '1'
    taps: '1.0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"LoRa channel"'
    type: complex
  states: {}
- name: sdrlora_decoder_0
  id: sdrlora_decoder
  parameters:
    bw: bw
    center_freq: '0'
    channel_filter_rx: 'True'
    cr: '1'
    cutoff_ratio: '1.15'
    fec_correct: 'True'
    has_crc: 'True'
    hop_freqs: '[]'
    hop_period: '0'
    implicit_header: 'False'
    interp_target_osf: '4'
    interpolate: 'True'
    invert_iq: 'False'
    ldro: '2'
    low_latency: 'False'
    max_payload_len: '251'
    min_osf: '2'
    numtaps: '255'
    payload_len: '0'
    pseudo_header: 'False'
    report_crc_errors: 'False'
    robust_sync: 'True'
    samp_rate: samp_rate
    search_tail_symbols: '24'
    sf: sf
    soft_decision: 'True'
    sync_phases: '0'
    sync_threshold: '5.5'
    sync_word: '[0x12]'
    trise: '50e-6'
    window: '0'
  states: {}
- name: sdrlora_encoder_0
  id: sdrlora_encoder
  parameters:
    amplitude: '1.0'
    burst_tail: '-1'
    bw: bw
    cfo_ppm: '0'
    cr: '1'
    dst: '0'
    f0: freq
    has_crc: 'True'
    hop_freqs: '[]'
    hop_period: '0'
    implicit_header: 'False'
    invert_iq: 'False'
    ldro: '2'
    lead_in: '-1'
    phi0: '0.0'
    preamble_symbols: '8'
    pseudo_header: 'False'
    samp_rate: samp_rate
    seqn: '0'
    sf: sf
    src: '0'
    sync_word: '[0x12]'
    t0_frac: '0.0'
    trise: '50e-6'
  states: {}
- name: sdrlora_packet_print_0
  id: sdrlora_packet_print
  parameters:
    label: ''
    show_hex: 'False'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, sdrlora_encoder_0, pdus]
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', qtgui_waterfall_sink_x_0, '0']
- [channels_channel_model_0, '0', sdrlora_decoder_0, '0']
- [sdrlora_decoder_0, pdus, sdrlora_packet_print_0, pdus]
- [sdrlora_encoder_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
