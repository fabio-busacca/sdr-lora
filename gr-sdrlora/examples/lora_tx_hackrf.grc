options:
  parameters:
    author: SDR-LoRa
    description: 'LoRa transmitter: it sends ''Hello LoRa!'' once a second, with standard LoRa framing at SF7, 125 kHz and CR 4/5, with a CRC. Therefore, an SX127x node with the same settings receives it.'
    generate_options: qt_gui
    id: lora_tx_hackrf
    output_language: python
    title: LoRa transmitter (HackRF)
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 868.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: tx_vga
  id: variable
  parameters:
    value: '20'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(11, list(b"Hello LoRa!")))
    period: '1000'
  states: {}
- name: sdrlora_encoder_0
  id: sdrlora_encoder
  parameters:
    amplitude: '1.0'
    burst_tail: '-1'
    bw: bw
    cfo_ppm: '0'
    cr: '1'
    dst: '0'
    f0: freq
    has_crc: 'True'
    hop_freqs: '[]'
    hop_period: '0'
    implicit_header: 'False'
    invert_iq: 'False'
    ldro: '2'
    lead_in: '-1'
    phi0: '0.0'
    preamble_symbols: '8'
    pseudo_header: 'False'
    samp_rate: samp_rate
    seqn: '0'
    sf: sf
    src: '0'
    sync_word: '[0x12]'
    t0_frac: '0.0'
    trise: '50e-6'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: tx_vga
  states: {}

connections:
- [blocks_message_strobe_0, strobe, sdrlora_encoder_0, pdus]
- [sdrlora_encoder_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
